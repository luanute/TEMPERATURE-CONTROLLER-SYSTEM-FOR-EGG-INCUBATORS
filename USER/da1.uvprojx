# Keil uVision project da1.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: da1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\FWlib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group FWlib
    ../FWlib/src/: delay_sys.c get_clk.c i2c.c led7seg.c MAX31865_lib.c rtc.c stm32f1_gpio.c stm32f1_i2c.c stm32f1_spi_driver.c LCD_I2C.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
