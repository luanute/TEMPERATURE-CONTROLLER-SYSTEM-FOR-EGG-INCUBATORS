# Keil uVision project main.uvprojx, settings and files
target NEW Prj (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\REG\DRIVERS\inc;..\..\REG\get_clk;..\..\LCD_I2C;..\..\Max31865;..\..\REG\SPI_Driver;..\..\led7seg;..\..\REG\RTC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c
  group Drivers
    ../../REG/DRIVERS/src/: stm32f1_gpio.c delay_sys.c i2c.c
    ../../REG/get_clk/: get_clk.c
    ../../LCD_I2C/: LCD_I2C.c
    ../../Max31865/: MAX31865_lib.c
    ../../REG/SPI_Driver/: stm32f1_spi_driver.c
    ../../led7seg/: led7seg.c
    ../../REG/RTC/: rtc.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
